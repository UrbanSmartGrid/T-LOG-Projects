# IAR project ATTINY416XNANO.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-arch4-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny416 ATtiny416
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny416.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCNearHeapSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: i2c.c main.c Memory.c
